options:
  parameters:
    generate_options: qt_gui
    id: file_in_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: bw/2-samp_rate/sps
  states: {}
- name: access_code
  id: variable_header_format_default
  parameters:
    access_code: '"0001011011101000110100110111011100010101000111000111000100101101"'
    bps: '1'
    threshold: '0'
  states: {}
- name: bfsk
  id: variable_constellation
  parameters:
    const_points: '[-1,1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bw
  id: variable
  parameters:
    value: 0.820e6
  states: {}
- name: inter_header
  id: variable_header_format_default
  parameters:
    access_code: '"0001011011101000110100110111011100010101000111000111000100101101"'
    bps: '1'
    threshold: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '52'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shuyusihan/test_decode.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/shuyusihan/下载/RX_BLUE_ganrao_1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: '"cent_freq"'
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: '"bw"'
  states: {}
- name: blocks_msgpair_to_var_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: '"access_code"'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*2
    type: complex
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1011011101000110100110111011100010101000111000111000100101101'
    tagname: pack_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: samp_rate/(2*math.pi*D)
  states: {state: disabled}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ZMQ PULL + JSON 解析
      - 内部创建 ZMQ PULL socket，接收 JSON 消息
      - 解析出 center_freq_mhz, bandwidth_mhz, access_code
      - 输出三个 message 端口: freq (int), bw (int), access_code (string)
      """

      import json
      import threading
      import zmq
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          def __init__(self, endpoint="tcp://127.0.0.1:5555", bind=False,rx_type = "inter"):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ JSON Pull Parser (int freq/bw + access_code)',
                  in_sig=None,
                  out_sig=None
              )
              if rx_type not in ["inter", "boardcast"]:
                  raise Exception("rx_type must be 'inter' or 'boardcast'")
              else:
                  self.rx_type = rx_type
              self.endpoint = endpoint
              self.bind = bind
              self.running = False
              self.thread = None

              # 注册三个输出端口
              self.message_port_register_out(pmt.intern('freq'))        # int
              self.message_port_register_out(pmt.intern('bw'))          # int
              self.message_port_register_out(pmt.intern('access_code')) # string

              # 启动接收线程
              self.start_receiver()

          def start_receiver(self):
              self.running = True
              self.thread = threading.Thread(target=self.receiver_loop)
              self.thread.daemon = True
              self.thread.start()

          def receiver_loop(self):
              context = zmq.Context()
              socket = context.socket(zmq.SUB)

              socket.setsockopt(zmq.CONFLATE, 1)      # 只保留最新命令
              socket.setsockopt(zmq.SUBSCRIBE, b"")    # 订阅所有主题
              socket.setsockopt(zmq.RCVTIMEO, 10000)   # 30秒接收超时，防止无限期阻塞
              if self.bind:
                  socket.bind(self.endpoint)
                  print(f"[ZMQ] Binding PULL to {self.endpoint}")
              else:
                  socket.connect(self.endpoint)
                  print(f"[ZMQ] Connecting PULL to {self.endpoint}")

              while self.running:
                  try:
                      msg_bytes = socket.recv()
                      self.process_message(msg_bytes)
                  except zmq.Again:
                      print("[ZMQ] Receive timeout, no message received")
                      continue    
                  except zmq.ZMQError as e:
                      print(f"[ZMQ] Error: {e}")
                      break
                  except Exception as e:
                      print(f"[ZMQ] Unexpected error: {e}")
                      break

              socket.close()
              context.term()
              print("[ZMQ] Receiver thread stopped")
              if self.delay > 0:
                  time.sleep(self.delay)

          def process_message(self, msg_bytes):
              try:
                  s = msg_bytes.decode('utf-8')
                  data = json.loads(s)
              except Exception as e:
                  print(f"[Parser] JSON decode error: {e}")
                  return
              data = data[self.rx_type]
              # 提取字段，缺失时使用默认值并报警
              freq_val = data.get('center_freq')
              bw_val   = data.get('bandwidth')
              code_val = data.get('access_code')

              if freq_val is None or bw_val is None or code_val is None:
                  missing = []
                  if freq_val is None: missing.append('center_freq')
                  if bw_val is None: missing.append('bandwidth')
                  if code_val is None: missing.append('access_code')
                  print(f"[Parser] Missing keys: {missing} in {data.keys()}")
                  return

              # 转换为 int (截断小数)
              freq_int = int(freq_val)
              bw_int   = int(bw_val)

              # 发送消息
              self.message_port_pub(pmt.intern('freq'), 
                                    pmt.cons(pmt.intern('freq'), pmt.from_long(freq_int)))
              self.message_port_pub(pmt.intern('bw'), 
                                    pmt.cons(pmt.intern('bw'), pmt.from_long(bw_int)))
              self.message_port_pub(pmt.intern('access_code'), 
                                    pmt.cons(pmt.intern('access_code'), pmt.intern(code_val)))

              print(f"[Parser] Sent: freq={freq_int} MHz, bw={bw_int} MHz, access_code={code_val}")

          def stop(self):
              self.running = False
              if self.thread and self.thread.is_alive():
                  self.thread.join(timeout=2.0)

          def __del__(self):
              self.stop()
    bind: 'False'
    endpoint: '''tcp://127.0.0.1:5555'''
    rx_type: '''inter'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:11451"'
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_agc_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_gfsk_demod_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [epy_block_0, access_code, blocks_msgpair_to_var_1_0, inpair]
- [epy_block_0, bw, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, freq, blocks_msgpair_to_var_0, inpair]
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_0, '0']
- [rational_resampler_xxx_0, '0', digital_gfsk_demod_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
