options:
  parameters:
    author: dfdtc
    copyright: dfdtc
    generate_options: qt_gui
    id: unify_source_demod
    output_language: python
    title: unify_source_demod
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: bw/2-samp_rate/sps
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"0001011011101000110100110111011100010101000111000111000100101101"'
  states: {}
- name: bfsk
  id: variable_constellation
  parameters:
    const_points: '[-1,1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: boardcast_LPF
  id: variable_low_pass_filter_taps
  parameters:
    beta: '40'
    cutoff_freq: 535e3/2
    gain: '1.0'
    samp_rate: 2e6
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: boardcast_bw
  id: variable
  parameters:
    value: 267.5e3
  states: {}
- name: boardcast_delta
  id: variable
  parameters:
    value: 432.7e6-433.2e6
  states: {}
- name: bw
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: cent_freq
  id: variable
  parameters:
    value: 433.2e6
  states: {}
- name: inter1_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 935e3/2
    gain: '1.0'
    samp_rate: 2e6
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: inter2_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 855e3/2
    gain: '1.0'
    samp_rate: 2e6
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: inter3_LPF
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 245e3/2
    gain: '1.0'
    samp_rate: 2e6
    width: 5e3
    win: window.WIN_BLACKMAN
  states: {}
- name: inter_LPF
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate*2, 467.5e3,6e3, window=window.WIN_BLACKMAN)
  states: {}
- name: inter_bw
  id: variable
  parameters:
    value: 470e3
  states: {}
- name: inter_delta
  id: variable
  parameters:
    value: 432.7e6-432.2e6
  states: {}
- name: inv_ook
  id: variable_constellation
  parameters:
    const_points: '[0,1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[1, 0]'
    type: calcdist
  states: {}
- name: ook
  id: variable_constellation
  parameters:
    const_points: '[0,1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: samp_fc
  id: variable
  parameters:
    value: 432.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '52'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./test_decode.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./test_decode.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/shuyusihan/下载/RX_BLUE_ganrao_1
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: boardcast_delta
    sample_rate: 2e6
  states: {}
- name: blocks_freqshift_cc_1
  id: blocks_freqshift_cc
  parameters:
    freq: inter_delta
    sample_rate: 2e6
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: '"samp_fc"'
  states: {}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: '"inter_bw"'
  states: {}
- name: blocks_msgpair_to_var_1_0
  id: blocks_msgpair_to_var
  parameters:
    target: '"inter_LPF"'
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: '"boardcast_delta"'
  states: {}
- name: blocks_msgpair_to_var_2_0
  id: blocks_msgpair_to_var
  parameters:
    target: '"inter_delta"'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*2
    type: complex
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"0001011011101000110100110111011100010101000111000111000100101101"'
    tagname: pack_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"0010111101101111010011000111010010111001000101000100100100101110"'
    tagname: pack_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: samp_rate/(2*math.pi*boardcast_bw)
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: samp_rate/(2*math.pi*inter_bw)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: ZMQ PULL + JSON 解析
      - 内部创建 ZMQ PULL socket，接收 JSON 消息
      """

      import json
      import threading
      import zmq
      from gnuradio import gr
      import pmt
      import time
      from gnuradio.filter import firdes, window
      BLUE_FC = 434.42e6
      RED_FC  = 432.7e6 

      class blk(gr.sync_block):
          def __init__(self,samp_rate = 2e6, endpoint="tcp://127.0.0.1:5555", bind=False):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ JSON Pull Parser (int freq/bw + access_code)',
                  in_sig=None,
                  out_sig=None
              )
              self.samp_fc = RED_FC
              self.samp_rate = samp_rate
              self.endpoint = endpoint
              self.bind = bind
              self.running = False
              self.thread = None

              self.inter1_LPF = firdes.low_pass(1, samp_rate*2, 467.5e3,6e3, window=window.WIN_BLACKMAN)
              self.inter2_LPF = firdes.low_pass(1, samp_rate*2, 467.5e3,6e3, window=window.WIN_BLACKMAN)
              self.inter3_LPF = firdes.low_pass(1, samp_rate*2, 467.5e3,6e3, window=window.WIN_BLACKMAN)
              self.current_inter_LPF = self.inter1_LPF

              # 注册输出端口
              self.message_port_register_out(pmt.intern('samp_fc')) #int
              self.message_port_register_out(pmt.intern('boardcast_delta_freq')) #int
              self.message_port_register_out(pmt.intern('inter_delta_freq'))     # int
              self.message_port_register_out(pmt.intern('inter_bw'))             # int
              self.message_port_register_out(pmt.intern('inter_LPF'))           # taps

              # 启动接收线程
              self.start_receiver()

          def start_receiver(self):
              self.running = True
              self.thread = threading.Thread(target=self.receiver_loop)
              self.thread.daemon = True
              self.thread.start()

          def receiver_loop(self):
              context = zmq.Context()
              socket = context.socket(zmq.SUB)

              socket.setsockopt(zmq.CONFLATE, 1)      # 只保留最新命令
              socket.setsockopt(zmq.SUBSCRIBE, b"")    # 订阅所有主题
              socket.setsockopt(zmq.RCVTIMEO, 10000)   # 30秒接收超时，防止无限期阻塞
              if self.bind:
                  socket.bind(self.endpoint)
                  print(f"[ZMQ] Binding PULL to {self.endpoint}")
              else:
                  socket.connect(self.endpoint)
                  print(f"[ZMQ] Connecting PULL to {self.endpoint}")

              while self.running:
                  try:
                      msg_bytes = socket.recv()
                      self.process_message(msg_bytes)
                  except zmq.Again:
                      print("[ZMQ] Receive timeout, no message received")
                      continue    
                  except zmq.ZMQError as e:
                      print(f"[ZMQ] Error: {e}")
                      break
                  except Exception as e:
                      print(f"[ZMQ] Unexpected error: {e}")
                      break

              socket.close()
              context.term()
              print("[ZMQ] Receiver thread stopped")
              if self.delay > 0:
                  time.sleep(self.delay)

          def process_message(self, msg_bytes):
              try:
                  s = msg_bytes.decode('utf-8')
                  data = json.loads(s)
              except Exception as e:
                  print(f"[Parser] JSON decode error: {e}")
                  return
              
              data_boardcast = data["boardcast"]
              data_inter = data["inter"]

              self.team = data_boardcast["team"]
              if self.team == "red":
                  self.samp_fc = RED_FC
              elif self.team == "blue":
                  self.samp_fc = BLUE_FC

              boardcast_delta = self.samp_fc - data_boardcast.get("center_freq")
              
              inter_level = data_inter["level"]
              if inter_level == 1:
                  self.current_inter_LPF = self.inter1_LPF
              elif inter_level == 2:
                  self.current_inter_LPF = self.inter2_LPF
              elif inter_level == 3:
                  self.current_inter_LPF = self.inter3_LPF

              inter_delta = self.samp_fc - data_inter.get("center_freq")
              inter_bw = data_inter.get("bandwidth")

              # 提取字段，缺失时使用默认值并报警

              if boardcast_delta is None or inter_delta is None or inter_bw is None:
                  missing = []
                  if boardcast_delta is None: missing.append('boardcast_delta')
                  if inter_delta is None: missing.append('inter_delta')
                  if inter_bw is None: missing.append('inter_bw')
                  print(f"[Parser] Missing keys: {missing} in {data.keys()}")
                  return

              # 转换为 int (截断小数)
              boardcast_delta_int = int(boardcast_delta)
              inter_delta_int = int(inter_delta)
              inter_bw_int = int(inter_bw)

              # 发送消息
              self.message_port_pub(pmt.intern('samp_fc'), 
                                    pmt.cons(pmt.intern('samp_fc'), pmt.from_long(self.samp_fc)))
              self.message_port_pub(pmt.intern('boardcast_delta'), 
                                    pmt.cons(pmt.intern('boardcast_delta'), pmt.from_long(boardcast_delta_int)))
              self.message_port_pub(pmt.intern('interface_delta'), 
                                    pmt.cons(pmt.intern('interface_delta'), pmt.from_long(inter_delta_int)))
              self.message_port_pub(pmt.intern('inter_bw'), 
                                    pmt.cons(pmt.intern('inter_bw'), pmt.from_long(inter_bw_int)))
              self.message_port_pub(pmt.intern('inter_LPF'), 
                                    pmt.cons(pmt.intern('inter_LPF'), pmt.cons(pmt.intern("inter_LPF"), pmt.init_f32vector(len(self.current_inter_LPF), self.current_inter_LPF))))
              print("--------------------------------")
              print(f"[Parser] Current team: {self.team},")
              print(f"samp_fc: {self.samp_fc/1e6} MHz,") 
              print(f"boardcast_delta: {boardcast_delta_int} Hz,")
              print(f"inter_delta: {inter_delta_int} Hz,")
              print(f"inter_bw: {inter_bw_int} Hz")
              print("--------------------------------")
          def stop(self):
              self.running = False
              if self.thread and self.thread.is_alive():
                  self.thread.join(timeout=2.0)

          def __del__(self):
              self.stop()
    bind: 'False'
    endpoint: '''tcp://127.0.0.1:5555'''
    samp_rate: 2e6
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '2'
    taps: boardcast_LPF
    type: ccc
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: '2'
    taps: inter_LPF
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(2e6)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(samp_fc)
    gain1: '''hybrid'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(2e6)
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import fft
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:5559"'
    hwm: '4096'
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:5559"'
    hwm: '4096'
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_agc_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_freqshift_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_freqshift_cc_1, '0', fft_filter_xxx_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_pub_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_gfsk_demod_0_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [epy_block_0, boardcast_delta_freq, blocks_msgpair_to_var_2, inpair]
- [epy_block_0, inter_LPF, blocks_msgpair_to_var_1_0, inpair]
- [epy_block_0, inter_bw, blocks_msgpair_to_var_1, inpair]
- [epy_block_0, inter_delta_freq, blocks_msgpair_to_var_2_0, inpair]
- [epy_block_0, samp_fc, blocks_msgpair_to_var_0, inpair]
- [fft_filter_xxx_0, '0', digital_gfsk_demod_0, '0']
- [fft_filter_xxx_1, '0', digital_gfsk_demod_0_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_0, '0']
- [iio_pluto_source_0, '0', blocks_freqshift_cc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
