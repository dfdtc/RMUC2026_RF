options:
  parameters:
    generate_options: qt_gui
    id: file_in_test
    output_language: python
    title: file_in_test
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: bw/2
  states: {}
- name: bfsk
  id: variable_constellation
  parameters:
    const_points: '[-1,1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: bw
  id: variable
  parameters:
    value: 0.820e6
  states: {}
- name: inter_header
  id: variable_header_format_default
  parameters:
    access_code: '"0001011011101000110100110111011100010101000111000111000100101101"'
    bps: '1'
    threshold: '0'
  states: {}
- name: ook
  id: variable_constellation
  parameters:
    const_points: '[0,1]'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '4'
    rot_sym: '1'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '52'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: samp_rate/sps
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '4'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_1
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*D)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shuyusihan/test_decode.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/shuyusihan/下载/RX_BLUE_ganrao_1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*2
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '1011011101000110100110111011100010101000111000111000100101101'
    tagname: pack_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: bfsk
    damping: '1.0'
    loop_bw: '0.046'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '0.85'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.gaussian(1.2, sps, 0.35, 60)
    type: fff
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(bw)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''hybrid'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_2_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Baseband"'
    size: '2048'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:11451"'
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_agc_xx_1, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [fir_filter_xxx_0_0, '0', analog_agc_xx_1, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_2_0_1, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
