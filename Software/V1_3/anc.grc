options:
  parameters:
    generate_options: qt_gui
    id: anc
    output_language: python
    title: anc
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: freq_tune
  id: variable_qtgui_range
  parameters:
    label: freq_tune
    start: '-1000'
    step: '1'
    stop: '8000'
    value: '0'
  states: {}
- name: phase_shift
  id: variable_qtgui_range
  parameters:
    label: phase_shift
    start: '-1000'
    step: '5'
    stop: '8000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: phase_shift
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: phase_shift
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase_shift
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '2'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '15'
    type: byte
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: (2*math.pi)*D
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (165, 0, 6, 0, 153, 10, 6, 65, 65, 65, 65, 65, 65, 189, 45)
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-3,-1,1,3]'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class pi_pdu_controller_v2(gr.sync_block):
          def __init__(self, kp=0.1, ki=0.01, setpoint=0.1, samp_rate=32000.0):
              gr.sync_block.__init__(
                  self,
                  name='PI PDU Controller (Setpoint 0.1)',
                  in_sig=[np.float32],
                  out_sig=None
              )
              self.kp = kp
              self.ki = ki
              self.setpoint = setpoint
              self.dt = 1.0 / samp_rate

              self.integrator = 0.0
              self.i_limit = 180.0  # 积分限幅，防止饱和

              # 注册 PDU 输出端口
              self.message_port_register_out(pmt.intern("pdu_out"))

          def work(self, input_items, output_items):
              control_out = 100
              in0 = input_items[0]

              # 为了防止 PDU 发送频率过高击垮调度器
              # 我们只取当前缓冲区最后一个样本的控制结果进行异步输出
              if len(in0) > 0:
                  last_val = in0[-1]

                  # 1. 计算误差：目标是 0.1
                  error = self.setpoint - last_val

                  # 2. 更新积分项（带限幅）
                  self.integrator += error * self.dt

                  #self.integrator = max(min(self.integrator, self.i_limit), -self.i_limit)

                  # 3. 计算 PI 输出
                  control_out = (self.kp * error) + (self.ki * self.integrator)
                  # 构造 PDU: (dictionary, data_vector)
                  p = pmt.from_double(control_out)

                  self.message_port_pub(pmt.intern("pdu_out"),
                                        pmt.cons(pmt.intern("phase"),p))

              # 消耗掉所有输入采样点
              return len(in0)
    ki: '38'
    kp: '3.15'
    samp_rate: samp_rate
    setpoint: '0.5'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: 333000000+freq_tune
    samplerate: int(samp_rate)
    type: fc32
    uri: '"192.168.3.1"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '333000000'
    gain1: '''manual'''
    manual_gain1: '9'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"192.168.3.1"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"org"'
    nconnections: '2'
    size: '384'
    srate: samp_rate
    type: complex
    update_time: '0.3'
    ymax: '4'
    ymin: '-4'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"add"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.25'
    gain: '4'
    interp: '4'
    ntaps: 11*4
    samp_rate: samp_rate
    sym_rate: 500e3
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [blocks_char_to_float_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [blocks_multiply_xx_0, '0', iio_pluto_sink_0, '0']
- [blocks_phase_shift_0, '0', iio_pluto_sink_0, '0']
- [blocks_phase_shift_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_map_bb_0, '0']
- [blocks_rms_xx_1, '0', epy_block_0, '0']
- [blocks_rms_xx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vco_c_0, '0', blocks_phase_shift_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, pdu_out, blocks_msgpair_to_var_0, inpair]
- [iio_pluto_source_0, '0', blocks_rms_xx_1, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '1']
- [root_raised_cosine_filter_0_0_0, '0', blocks_vco_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
