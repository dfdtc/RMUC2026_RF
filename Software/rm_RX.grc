options:
  parameters:
    generate_options: qt_gui
    id: rm_rx
    output_language: python
    title: rm_rx
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: symb_rate/4
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: pam4
  id: variable_constellation
  parameters:
    const_points: '[-3,-1,1,3]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '1'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*D)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-70'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.78'
    type: float
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: pam4
    damping: '1.0'
    loop_bw: '0.1'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.8'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class four_fsk_slicer(gr.sync_block):
          """
          4FSK Hard Slicer
          Input: Float symbols (approx -3, -1, 1, 3)
          Output: Bytes (0, 1, 2, 3 based on mapping)
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="4FSK Slicer",
                  in_sig=[np.float32],
                  out_sig=[np.uint8])

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              # 矢量化操作提高效率
              # 判决门限：-2, 0, 2

              # 逻辑：
              # val < -2  -> -3 (Symbol 0, bits 00)
              # -2 < val < 0 -> -1 (Symbol 1, bits 01)
              # 0 < val < 2  -> 1  (Symbol 3, bits 11 - Gray)
              # val > 2   -> 3  (Symbol 2, bits 10 - Gray)

              # 使用 np.select 或者简单的比较

              cond_neg3 = in0 < -1.85
              cond_neg1 = (in0 >= -1.85) & (in0 < 0.0)
              cond_pos1 = (in0 >= 0.0) & (in0 < 1.85)
              cond_pos3 = in0 >= 1.85

              out[:] = (0 * cond_neg3 +
                        1 * cond_neg1 +
                        2 * cond_pos1 +
                        3 * cond_pos3).astype(np.uint8)

              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from scipy import signal
      import struct

      class fsk_burst_demod_rrc(gr.basic_block):
          def __init__(self, sps=4, alpha=0.25, ntaps=44, threshold=12.0, payload_bytes=14):
              gr.basic_block.__init__(self,
                  name="4-FSK RRC Correlation Demod",
                  in_sig=[np.float32],
                  out_sig=[np.uint8])

              self.sps = sps
              self.threshold = threshold
              self.payload_bytes = payload_bytes
              self.preamble_bytes = 1



              # 预计算核

              self.kernel = np.array(
                      [-0.3573050820141748, 0.5660324802079747, 1.2540338399449016, 1.6295843398401122, 1.6540407856806771, 1.3361034273782317, 0.751107591189669, 0.05043177497731362, -0.5937277177999305, -0.9785924463822805, -1.0780863103973495, -0.9735427298716328, -0.8530721779041428, -0.8496851308974418, -1.0996978799392936, -1.6034189664941476, -2.2065817403116985, -2.8258390531562303, -3.2484240942060123, -3.380621099394902, -3.2539607537620547, -3.010055647627655, -2.8195794555849996, -2.7830997744361694, -2.9247430368311886, -3.0553742929915426, -3.1276277405435704, -3.1159436582249245, -3.0502972667543005, -2.965491326761916, -2.8480935627121218, -2.623313845849911, -2.1740644196075953, -1.4963902421714717, -0.6214243499251842, 0.2802205824933558, 0.959380227235302, 1.1783752469166406, 0.8126400837735933, -0.08596178463524357, -1.2822550094286638, -2.522246206339441, -3.490881105705776, -3.978374440835261], dtype=np.float32)

              self.buffer = np.array([], dtype=np.float32)
              self.state = "SEARCH"
              self.samples_per_packet = (self.preamble_bytes + self.payload_bytes) * 4 * sps

          def general_work(self, input_items, output_items):
              in0 = input_items
              out = output_items
              self.buffer = np.append(self.buffer, in0)

              produced = 0
              while True:
                  if self.state == "SEARCH":
                      # 需要足够的长度进行互相关
                      if len(self.buffer) < len(self.kernel) + self.samples_per_packet:
                          break

                      # 滑动相关 (仅搜索缓冲区起始的一段)
                      search_len = min(len(self.buffer), 512)
                      corr = signal.correlate(self.buffer[:search_len], self.kernel, mode='valid')

                      peak_idx = np.argmax(corr)
                      if corr[peak_idx] > self.threshold:
                          #print("valid")
                          # 匹配成功。对于 'valid' 模式，峰值索引 peak_idx
                          # 对应的正是 kernel 完全对齐 buffer[peak_idx : peak_idx+len(kernel)] 的位置
                          # 最佳采样点通常在 preamble 结束后的第一个 payload 符号处
                          self.sample_ptr = peak_idx + len(self.kernel)
                          self.state = "EXTRACT"
                      else:
                          # 未找到，修剪缓冲区防止内存溢出
                          self.buffer = self.buffer[search_len - len(self.kernel):]
                          break

                  elif self.state == "EXTRACT":
                      # 检查剩余样本是否足够覆盖 payload
                      payload_samples_needed = self.payload_bytes * 4 * self.sps
                      if len(self.buffer) < self.sample_ptr + payload_samples_needed:
                          break

                      # 开始每隔 SPS 个样本抽取一个点（抽取在同步后执行）
                      payload_stream = self.buffer[self.sample_ptr : self.sample_ptr + payload_samples_needed]
                      decision_points = payload_stream[::self.sps]

                      # 解码符号并组包
                      packet_bytes = []
                      for i in range(0, len(decision_points), 4):
                          byte_val = 0
                          for j in range(4):
                              v = decision_points[i+j]
                              # 4FSK 判决门限 (假设已经归一化到 -3, -1, 1, 3)
                              if v > 2.0: bits = 0b11 # +3
                              elif v > 0: bits = 0b10 # +1
                              elif v > -2.0: bits = 0b01 # -1
                              else: bits = 0b00 # -3
                              byte_val = (byte_val << 2) | bits
                              #byte_val = int("{:08b}".format(byte_val)[::-1],2)
                          packet_bytes.append(byte_val)

                      # 截断到请求的长度并添加 Tag
                      final_payload = packet_bytes[:self.payload_bytes]

                      # 打标：在当前输出流的起始位置添加 packet_len 标签
                      tag_index = self.nitems_written(0) + produced
                      self.add_item_tag(0, tag_index, pmt.intern("packet_len"), pmt.from_long(self.payload_bytes))

                      # 输出
                      out[produced : produced + len(final_payload)] = final_payload
                      produced += len(final_payload)

                      # 重置状态并清理 buffer
                      self.buffer = self.buffer[self.sample_ptr + payload_samples_needed:]
                      self.state = "SEARCH"

              self.consume(0, len(in0))
              return produced
    alpha: '0.25'
    ntaps: '44'
    payload_bytes: '11'
    sps: '4'
    threshold: '100'
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from scipy import signal

      class fsk_corr_scorer(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="FSK Correlation Scorer",
                  in_sig=[np.float32],
                  out_sig=[np.float32])

              # 预计算核 (保持原有数值)
              self.kernel = np.array(
                      [-0.3573050820141748, 0.5660324802079747, 1.2540338399449016, 1.6295843398401122, 1.6540407856806771, 1.3361034273782317, 0.751107591189669, 0.05043177497731362, -0.5937277177999305, -0.9785924463822805, -1.0780863103973495, -0.9735427298716328, -0.8530721779041428, -0.8496851308974418, -1.0996978799392936, -1.6034189664941476, -2.2065817403116985, -2.8258390531562303, -3.2484240942060123, -3.380621099394902, -3.2539607537620547, -3.010055647627655, -2.8195794555849996, -2.7830997744361694, -2.9247430368311886, -3.0553742929915426, -3.1276277405435704, -3.1159436582249245, -3.0502972667543005, -2.965491326761916, -2.8480935627121218, -2.623313845849911, -2.1740644196075953, -1.4963902421714717, -0.6214243499251842, 0.2802205824933558, 0.959380227235302, 1.1783752469166406, 0.8126400837735933, -0.08596178463524357, -1.2822550094286638, -2.522246206339441, -3.490881105705776, -3.978374440835261], dtype=np.float32)

              # 设置 history 长度，确保每次 work 都能访问到足够的旧样本进行互相关
              self.set_history(len(self.kernel))

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              # 在 sync_block 中，如果设置了 history 为 K，
              # 则 len(in0) = noutput_items + K - 1
              # 我们对整段 buffer 进行 valid 模式的相关运算，得到长度为 noutput_items 的结果
              # 使用 numpy.correlate 或 scipy.signal.correlate 均可
              # 注意：为了性能，这里使用 numpy 的 correlate

              corr_result = signal.correlate(in0, self.kernel, mode='valid')

              # 填充到输出
              n_out = len(corr_result)
              out[:n_out] = corr_result

              return n_out
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      from scipy import signal

      class fsk_burst_tagger(gr.sync_block):
          def __init__(self, threshold=12.0):
              gr.sync_block.__init__(self,
                  name="FSK Burst Tagger",
                  in_sig=[np.float32],
                  out_sig=[np.float32]) # 修改为浮点输出，保持信号流不变

              self.threshold = threshold
              # 预计算核 (保持原有数值)
              self.kernel = np.array(
                      [-0.3573050820141748, 0.5660324802079747, 1.2540338399449016, 1.6295843398401122, 1.6540407856806771, 1.3361034273782317, 0.751107591189669, 0.05043177497731362, -0.5937277177999305, -0.9785924463822805, -1.0780863103973495, -0.9735427298716328, -0.8530721779041428, -0.8496851308974418, -1.0996978799392936, -1.6034189664941476, -2.2065817403116985, -2.8258390531562303, -3.2484240942060123, -3.380621099394902, -3.2539607537620547, -3.010055647627655, -2.8195794555849996, -2.7830997744361694, -2.9247430368311886, -3.0553742929915426, -3.1276277405435704, -3.1159436582249245, -3.0502972667543005, -2.965491326761916, -2.8480935627121218, -2.623313845849911, -2.1740644196075953, -1.4963902421714717, -0.6214243499251842, 0.2802205824933558, 0.959380227235302, 1.1783752469166406, 0.8126400837735933, -0.08596178463524357, -1.2822550094286638, -2.522246206339441, -3.490881105705776, -3.978374440835261], dtype=np.float32)

              self.buffer = np.array([], dtype=np.float32)
              self.skip_count = 0 # 用于防止在同一个峰值附近重复打标

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              # 将新数据存入缓冲区
              self.buffer = np.append(self.buffer, in0)

              # 如果缓冲区太短，无法进行相关运算，则直接消耗并返回
              if len(self.buffer) < len(self.kernel):
                  self.consume(0, len(in0))
                  return 0

              # 执行互相关
              # 我们只对新加入的数据及其前缀进行相关运算
              corr = signal.correlate(self.buffer, self.kernel, mode='valid')

              # 寻找超过阈值的峰值
              for i in range(len(corr)):
                  if corr[i] > self.threshold and self.skip_count == 0:
                      # 计算标签在全局流中的位置
                      # nitems_written(0) 是已输出的样本数
                      # i 是在当前 buffer 中的偏移
                      tag_index = self.nitems_written(0) + i

                      # 添加 Tag
                      self.add_item_tag(0, tag_index, pmt.intern("burst_detected"), pmt.PMT_T)

                      # 设置跳过计数，防止对同一个 preamble 的多个采样点重复触发 (通常设为核长度)
                      self.skip_count = len(self.kernel)

                  if self.skip_count > 0:
                      self.skip_count -= 1

              # 将输入直接透传到输出
              n_output = min(len(in0), len(out))
              out[:n_output] = in0[:n_output]

              # 这里的 buffer 管理：保留最后 kernel_len 个样本，以便下次搜索能跨越边界
              self.buffer = self.buffer[n_output:]

              self.consume(0, n_output)
              return n_output
    threshold: '175'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '5000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '433000000'
    gain1: '''manual'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2000000'
    type: fc32
    uri: '"192.168.3.1"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"BER"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '3'
    ymax: '5'
    ymin: '-0'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Corr_tag"'
    nconnections: '2'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_2_0_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Baseband"'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_2_0_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Symb
    label2: error
    name: '"CR_out"'
    nconnections: '2'
    size: '512'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', epy_block_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_1, '0', epy_block_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', epy_block_1_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_2_0_1, '0']
- [blocks_repack_bits_bb_1_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_2_0_2, '0']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_2_0_2, '1']
- [epy_block_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [epy_block_1, '0', blocks_uchar_to_float_0_0, '0']
- [epy_block_1_0, '0', qtgui_time_sink_x_2_0, '1']
- [epy_block_1_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [iio_pluto_source_0, '0', analog_simple_squelch_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
