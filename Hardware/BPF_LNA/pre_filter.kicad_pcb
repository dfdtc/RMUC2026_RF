# Repository dfdtc/RMUC2026_RF

File README.md:

# RMUC2026_RF

This is the pubilc repository of BNBU 2026 RMUC RF part of Radar

GNURadio workflow files and Python codes in /Software. PCB project and related mechanical parts model in /Hardware.

Notice the RF parameters in Tx&Rx code/workflow

More infomation about this repository, Please refer to: https://bbs.robomaster.com/article/1811559

## KiCad design Hardware/BPF_LNA/pre_filter.kicad_pcb

File Hardware/BPF_LNA/README.md:

### 简介

    这是一个简单的预选带通滤波器+LNA，关键器件是带通SAW滤波器B39431B3710U410，和LNA QPL9547；

    本设计期望使用一个比较优质的前置低噪声，降低系统噪声系数，使用预选滤波器，尽可能避免带外大信号干扰（但注意，无法过滤干扰源信号）；

    本设计由TypeC供电5V，实测工作功率<1W，支持从GH1.25受电或给其他设备串联供电，如果不需要可以不焊接。

### Tips

    SMA是板侧装*宽脚*型，普通型号可能勉强能安装，但是不太推荐。

### TODO

    屏蔽外壳还未完成，完成后可以使用SMA-KF，目前模型有问题，TypeC和螺纹开孔位置不对，欢迎贡献。

Parts:
C3, C4, C6, C7, C8: 100p; C_0402_1005Metric
C5: 1u; C_0805_2012Metric
D1: SMF6V0A; D_SMF
F1: 500ma PPTC; Fuse_1206_3216Metric
FB1: 120ohm; C_0805_2012Metric
H1, H2, H3, H4: M2.5; MountingHole_2.7mm_M2.5_DIN965_Pad_TopBottom
J1, J2: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
J3: USB_C_6P; USB_C_Receptacle_HRO_TYPE-C-31-M-17
J4: GH1.25_H; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
L1: 18n; L_0402_1005Metric
R2: 3.32k; R_0402_1005Metric
R3, R4: 5.1k; R_0402_1005Metric
U1: QPL9547; DFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.6mm
X1: B39431B3710U410; Filter_SAW_Epcos_DCC6C_3x3mm

Connections:
GND: C3.2, C4.2, C5.2, D1.2 (A2), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J1.2 (Ext), J2.2 (Ext), J3.A12 (GND), J3.B12 (GND), J3.SH (SHIELD), J4.2, J4.MP (MountPin), R3.2, R4.2, U1.3 (GND), U1.4 (GND), U1.5 (GND), U1.6 (~EN), U1.8 (GND), U1.9 (GND), X1.1 (GND), X1.3 (GND), X1.4 (GND), X1.6 (GND)
unnamed: C3.1, C4.1, C5.1, FB1.2, L1.1, R2.1
unnamed: C7.2, U1.2
unnamed: C8.1, L1.2, U1.7
unnamed: D1.1 (A1), F1.2, FB1.1
unnamed: C6.1, J1.1 (In)
unnamed: C8.2, J2.1 (In)
unnamed: J3.A5 (CC1), R3.1
unnamed: J3.B5 (CC2), R4.1
unnamed: F1.1, J3.A9 (VBUS), J3.B9 (VBUS), J4.1
unnamed: R2.2, U1.1 (Vb)
unnamed: C6.2, X1.2 (IN)
unnamed: C7.1, X1.5 (OUT)

Notes on the sheet:
注： 原则上使用四层板以及JLC04161H-7628层压结构

Board: 4 copper layers, 40.0 x 40.0 mm, 23 parts (0 on the bottom side), 13 nets.

File Hardware/BPF_LNA/pre_filter_BOM.csv:

"Reference","Qty","Value","DNP","Exclude from BOM","Exclude from Board","Footprint","Datasheet"
"C3,C4,C6,C7,C8","5","100p","","","","Capacitor_SMD:C_0402_1005Metric",""
"C5","1","1u","","","","Capacitor_SMD:C_0805_2012Metric",""
"D1","1","SMF6V0A","","","","Diode_SMD:D_SMF","https://www.vishay.com/doc?85881"
"F1","1","500ma PPTC","","","","Fuse:Fuse_1206_3216Metric",""
"FB1","1","120ohm","","","","Capacitor_SMD:C_0805_2012Metric",""
"J1,J2","2","Conn_Coaxial","","","","Connector_Coaxial:SMA_Amphenol_132289_EdgeMount",""
"J3","1","USB_C_6P","","","","Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-17","https://www.usb.org/sites/default/files/documents/usb_type-c.zip"
"J4","1","GH1.25_H","","","","Connector_JST:JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal",""
"L1","1","18n","","","","Inductor_SMD:L_0402_1005Metric",""
"R2","1","3.32k","","","","Resistor_SMD:R_0402_1005Metric",""
"R3,R4","2","5.1k","","","","Resistor_SMD:R_0402_1005Metric",""
"U1","1","QPL9547","","","","Package_DFN_QFN:DFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.6mm","https://www.qorvo.com/products/d/da007268"
"X1","1","B39431B3710U410","","","","Filter:Filter_SAW_Epcos_DCC6C_3x3mm",""

## Commit log (part)

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2026-03-20 Init and Synchronize existing work
2026-03-20 Update README
    Added information about the organization of this repository and some notice
2026-03-20 Fix line break and add ref
2026-03-20 fix: fix bug in rm_rx.py Fix Constellation setting in rm_rx.py Add rm_header.py and rm_rrc_pearm.py scripts
2026-03-20 feat: rename rm_header.py to rm_frame.py
2026-05-13 feat(Hardware) Add BPF_LNA; style(dir) Reorganized directory
    Add BPF_LNA hardware project;
    Reorganized directory prepare for future project, nochange to existing files.
2026-05-21 feat(Software) ADD V1_4 Code
2026-05-21 refactor(Software): refactor text_ana.py to improve code readability and maintainability
2026-05-21 feat(text_ana): reconstruct packet decode, remove statistics, and add packet decode test
2026-05-21 docs: Add copyright declaration for qt_zmq_client.py and tx.grc
2026-05-22 feat: Restore works
2026-05-22 feat: Also restore works...
2026-05-22 feat(Software): new flow zmq_decoder, major directory restructure!!
2026-05-22 feat: finished the prototype of TX; improved RX flow; reorganized the file structure
2026-05-22 feat(zmq_decoder): Update func output_result,let it accept solved
2026-05-23 docs(Software): add requirements.txt
2026-05-23 fix(boardcast_source_demod): use correct init access code for boardcast_source feat(lab): add sic and unify_source_demod
2026-05-24 feat(zmq_decoder): add data invert option in output_result
2026-05-24 doc: KICAD history pack
2026-05-24 feat(zmq_decoder): clear buffer when no SOF found
2026-05-31 Add readme for RMUC V1.4 RF design project
    This readme provides an overview of the project, including software usage, hardware details, and TODOs.
2026-06-01 dosc(pre_filter): add packed file of project
